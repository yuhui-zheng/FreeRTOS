# IAR project CORTEX_M0+_LPC51U68_IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC51U68 NXP LPC51U68
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_LPC51U68JBD64
  ICCARM.CCIncludePath2: ..\..\Source\include; ..\..\Source\portable\IAR\ARM_CM0; ..\Common\include; ..\CORTEX_M0+_LPC51U68_LPCXpresso\app; ..\CORTEX_M0+_LPC51U68_LPCXpresso\board\boards; ..\CORTEX_M0+_LPC51U68_LPCXpresso\CMSIS; ..\CORTEX_M0+_LPC51U68_LPCXpresso\component\lists; ..\CORTEX_M0+_LPC51U68_LPCXpresso\component\serial_manager; ..\CORTEX_M0+_LPC51U68_LPCXpresso\component\uart; ..\CORTEX_M0+_LPC51U68_LPCXpresso\device; ..\CORTEX_M0+_LPC51U68_LPCXpresso\drivers; ..\CORTEX_M0+_LPC51U68_LPCXpresso\IAR_specific; ..\CORTEX_M0+_LPC51U68_LPCXpresso\utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\CORTEX_M0+_LPC51U68_LPCXpresso\app
  OBJCOPY.OOCOutputFile: CORTEX_M0+_LPC51U68_IAR.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: C:\Users\yuhzheng\Documents\FreeRTOS\FreeRTOS\Demo\CORTEX_M0+_LPC51U68_LPCXpresso\IAR_specific\iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    app/: FreeRTOSConfig.h IntQueueTimer.c IntQueueTimer.h main.c main_blinky.c main_full.c
  group board
    board/boards/: board.c board.h clock_config.c clock_config.h peripherals.c peripherals.h pin_mux.c pin_mux.h
  group CMCIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h
  group component/lists
    component/lists/: generic_list.c generic_list.h
  group component/serial_manager
    component/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/uart
    component/uart/: uart.h usart_adapter.c
  group device
    device/: fsl_device_registers.h LPC51U68.h LPC51U68_features.h system_LPC51U68.c system_LPC51U68.h
  group drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_ctimer.c fsl_ctimer.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_iocon.h fsl_pint.c fsl_pint.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_usart.c fsl_usart.h
  group FreeRTOS
    ../../Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/include
    ../../Source/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRTOS/portable/IAR
    ../../Source/portable/IAR/ARM_CM0/: port.c portasm.s portmacro.h
  group FreeRTOS/portable/MemMang
    ../../Source/portable/MemMang/: heap_5.c
  group IAR_specific
    IAR_specific/: compiler_attributes.h iar_lib_power.a RegTest_IAR.s startup_LPC51U68.s
  group Minimal
    ../Common/Minimal/: blocktim.c countsem.c IntQueue.c recmutex.c
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console_conf.h fsl_str.c fsl_str.h
